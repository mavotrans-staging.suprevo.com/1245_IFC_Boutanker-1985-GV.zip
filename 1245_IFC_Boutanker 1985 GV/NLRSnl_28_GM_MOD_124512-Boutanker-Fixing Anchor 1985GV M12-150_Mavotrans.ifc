Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T10:45:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 10:45:36 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{A0BBE36D-80C2-4686-B646-B62BBEF7045F}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 10:45:35 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 10:45:35 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 10:45:35 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1245_Boutanker 1985 GV; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1245_Boutanker 1985 GV; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19:124512_M12-150mm, 1241512
In: Level 0
Type - Material: elektrolytisch verzinkt (2), onbehandeld kwaliteit 8.8 (2)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a (mm): 23 mm; d_nom: M12; I (mm): 35 mm; k (mm): 40 mm; L (mm): 150 mm
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 1241512; Beschrijving | Description: Boutanker | Fixing Anchor 1985 GV M12 x 150mm; Certificaten | Certification: CE + ETA-13/0401; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28.20; OmniClass Number: 23.25.10.27.11.11; OmniClass Title: Reinforcing Steel; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 124512_M12-150mm; URL: https://mavotrans.nl/boutanker-1985-gv.html; Verpakkingshoeveelheid | Sales packaging: Verkoop per stuk | Sold per piece; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Draadbus is gegalvaniseerd en de bout is onbehandeld, kwaliteit 8.8 | Socket is galvanized and bolt is untreated 8.8
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19; head height: 8 mm; length "a": 23 mm; length "l": 35 mm; radius "d-nom": 6 mm; radius 2: 9 mm; radius bottom ring: 20 mm; radius thread: 8 mm; radius wrench size: 11 mm; size "k": 40 mm; size bolt "d-nom": 12 mm; thickness steel: 1 mm; wrench size: 22 mm
Type - Pset_ProductRequirements - Category: Generic Models
Description: Boutanker | Fixing Anchor 1985 GV M12 x 150mm; Classification: 28.20 (Default Classification)
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19:124512_M12-150mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 120 mm; Depth: 120 mm
Constraints - Level: Level: Level 0; Offset: 100 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.00595143 m2; Volume: 0.0000211464 m3
Other - Family: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19: 124512_M12-150mm; Family and Type: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19: 124512_M12-150mm; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19: 124512_M12-150mm; Type Id: NLRSnl_28_GM_MOD_1245-Boutanker-Fixing Anchor 1985GV_Mavotrans_R19: 124512_M12-150mm
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover Settings: Rebar Cover 1
